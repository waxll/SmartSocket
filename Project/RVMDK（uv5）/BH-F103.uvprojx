# Keil uVision project BH-F103.uvprojx, settings and files
target WiFi_KEY (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WiFi_KEY +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\ESP8266;..\..\User\OLED;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/usart/: bsp_usart.c
    ../../User/OLED/: oled.c
    ../../User/ESP8266/: ESP8266.c
    ../../User/led/: bsp_led.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
